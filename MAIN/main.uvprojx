# Keil uVision project main.uvprojx, settings and files
target MAIN (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: M482LIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: main +hex
  AfterMake: fromelf --bin ".\Output\@L.axf" --output ".\Output\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\NUVOTON\M480\StdDriver\inc;..\..\NUVOTON\M480\Device\Include;.\LCD;..\MAIN;..\..\NUVOTON\M480\Drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group CMSIS
    ../../NUVOTON/M480/Device/: startup_M480.s system_M480.c
  group User
    ./: main.c
  group CFG
    ../CONFIG/NuClockConfig/ClockConfig/: ClockConfig.c
    ../CONFIG/NuPinConfig/PinConfig/: PinConfig.c
  group Lib
    ../../NUVOTON/M480/StdDriver/src/: clk.c delay.c ebi.c fmc.c gpio.c retarget.c sys.c timer.c eadc.c dac.c wdt.c i2c.c crc.c qei.c uart.c spi.c
    ../../NUVOTON/M480/Drivers/src/: i2cs.c
software components: CMSIS:CORE 5.5.0
